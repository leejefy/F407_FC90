# Keil uVision project FC90_V1.uvprojx, settings and files
target Ver1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FC90v1 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c include: ..\Common;..\CORE;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\USER\usart;..\lwip-1.4.1\port\STM32F4x7;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\include\lwip;..\lwip-1.4.1\port\STM32F4x7\Standalone;..\USER\LWIP_APP;..\USER\MALLOC;..\USER\MV88E63x;..\USER\switch\Include\h\driver;..\USER\switch\Include\h\msApi;..\USER\switch\Include\h\platform;..\USER\switch\sample\Include;..\USER\switch\Include;..\USER\phy\Include;..\USER\phy\Include\h\driver;..\USER\phy\Include\h\driver;..\USER\phy\Include\h\madApi;..\USER\phy\Include\h\platform;..\USER\phy\Include\h\macsec;..\USER\switch\sample\Include;..\USER\phy\sample\Initialization\firebat;..\USER\phy\sample
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40xx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Common
    ../Common/: common.c
  group LWIP
    ../lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group USER
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../USER/usart/: usart.c
    ../USER/LWIP_APP/: netconf.c UDP_SERVER.C
    ../USER/MALLOC/: malloc.c
    ../USER/MV88E63x/: stm32f4x7_eth_bsp.c
    ../USER/switch/src/msapi/: gtAdvVct.c gtAVB.c gtBrgFdb.c gtBrgStp.c gtBrgStu.c gtBrgVlan.c gtBrgVtu.c gtCCPVT.c gtEvents.c gtHiddenReg.c gtMisc.c gtPage2Access.c gtPCSCtrl.c gtPhyCtrl.c gtPhyInt.c gtPIRL.c gtPIRL2.c gtPIRL3.c gtPolicy.c gtPortCtrl.c gtPortLed.c gtPortPav.c gtPortPrioMap.c gtPortRateCtrl.c gtPortRmon.c gtPortStat.c gtPortStatus.c gtPriTable.c gtPTP.c gtQosMap.c gtSerdesCtrl.c gtSysConfig.c gtSysCtrl.c gtSysStatus.c gtTCAM.c gtUtils.c gtVct.c gtVersion.c gtWeight.c gtAdvVct_mad.c gtPhyCtrl_mad.c gtPhyInt_mad.c gtVct_mad.c
    ../USER/switch/src/driver/: gtDrvConfig.c gtDrvEvents.c gtHwCntl.c
    ../USER/switch/src/platform/: gtDebug.c gtMiiSmiIf.c gtSem.c platformDeps.c
    ../USER/switch/sample/Initialization/: ev96122mii.c msApiInit.c osSem.c qdSim.c
    ../USER/phy/src/madapi/: madCpCtrl.c madCpStatus.c madFbCtrl.c madIEEETest.c madInt.c madLoopback.c madMACCtrl.c madPatGen.c madPktGen.c madPortPTP.c madPTP.c madSMVct.c madStats.c madSyncClkCtrl.c madSysConfig.c madSysCtrl.c madVctAdv.c madVctAlt.c madVctExt.c madVctTdr.c madVersion.c madVod.c madWol.c madXmdioRegCtrl.c madXmdioRegStatus.c
    ../USER/phy/src/driver/: madDevConfig.c madDrvConfig.c madHwCntl.c madUtils.c
    ../USER/phy/src/platform/: madDebug.c madPlatformDeps.c madSem.c madSmiIf.c
    ../USER/phy/src/macfunc/macsec/: aescrypt.c aeskey.c aestab.c msecApi.c msecFunc.c
